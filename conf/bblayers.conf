## conf/bblayers.conf
```bitbake
TOPDIR := '${@os.path.dirname(os.path.dirname(FILE))}'
BBPATH = '${TOPDIR}:${HOME}/.oe'
BBFILES = ''
BBLAYERS = '${TOPDIR}/oe-core/meta'
```
